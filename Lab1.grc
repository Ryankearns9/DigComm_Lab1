options:
  parameters:
    author: Rkear
    generate_options: qt_gui
    id: Lab1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_entry
  parameters:
    label: Carrier Frequency
    type: real
    value: 900e3
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    label: Center_frequency
    type: real
    value: 900e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Rkear\Documents\Masters\Intro to DSP\GNU_Radio\Lab1\am_broadcast_02_c900k_s400k.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '4'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"With Carrier"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    name: '"With Carrier"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '2'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: audio
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: audio
  states: {}

connections:
- [analog_am_demod_cf_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_file_source_0, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [low_pass_filter_0, '0', analog_am_demod_cf_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
